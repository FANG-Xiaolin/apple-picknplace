Commit message: [main] sim interface init

File: asset/panda_arm_hand_cam.urdf (robot description, URDF)
Before this commit: robot panda, 15 links, 14 joints
Links:
- removed link panda_tool_tip
Joints:
- removed joint panda_tool_tip_joint
- joint panda_tool_tip_joint2: axis 0 0 0 -> 0 -1 -1
